# Repository igori5/inteldon_v1

File README.md:

# 強めの4chDCモタドラ
出力電流：かなり  
電源電圧：30Vまで  
制御側電源：5V  
インターフェース：CAN  
欠陥1：ハイサイド側の放熱が弱い  
欠陥2：デバッグ用UARTが逆

## KiCad design inteldon_v1.kicad_pcb

Parts:
C101, C102: 22p; C_0603_1608Metric
C103, C105: 1u; C_0603_1608Metric
C104, C106, C107, C108, C109, C110, C111, C112, C113: 0.1u; C_0603_1608Metric
C114, C115: 10u; CP_Elec_6.3x5.9
D101, D102, D103, D104: WS2812B-2020; LED_WS2812B-2020_PLCC4_2.0x2.0mm
D105, D106, D107, D108: LED; LED_0603_1608Metric
FB101: FerriteBead; L_0603_1608Metric
J101: Conn_02x07_Odd_Even; PinHeader_2x07_P1.27mm_Vertical_SMD
J102: Conn_01x02_Pin; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J103: Conn_01x02_Socket; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J104, J105: Conn_01x04_Socket; JST_XA_S04B-XASK-1_1x04_P2.50mm_Horizontal
R101, R102, R103, R104, R105, R106, R107: 10k; R_0603_1608Metric
R108, R109, R110, R111: R; R_0603_1608Metric
R112: 120; R_0603_1608Metric
SW101: SW_DIP_x04; SO-8_5.3x6.2mm_P1.27mm
SW102: SW_SPDT; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW103: SW_Push; SW_PUSH_6mm
U101: MIC5504-3.3YM5; SOT-23-5
U102: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U103: L7812; TO-252-2
U104: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm
Y101: 16MHz; Crystal_SMD_HC49-SD

Connections:
+3.3V: C104.1, C105.1, FB101.1, J101.3, R104.1, R105.1, R106.1, R107.1, R108.1, U101.5 (VOUT), U102.1 (VDD), U102.17 (VDD), U104.5 (Vref); also elsewhere on the board
+3.3VA: FB101.2, U102.5 (VDDA)
+5V: C103.1, C108.1, C109.1, C110.1, C111.1, C112.1, D101.4 (VDD), D102.4 (VDD), D103.4 (VDD), D104.4 (VDD), J104.1, J105.1, R102.1, R109.1, U101.1 (VIN), U104.3 (VDD)
+12V: C107.1, C114.1, C115.1, R110.1, U103.3 (OUT); also elsewhere on the board
+BATT: C106.1, J102.2, J103.2, R111.1, U103.1 (IN); also elsewhere on the board
BOOT0: R101.1, U102.31 (BOOT0)
CANH: J104.2, J105.2, SW102.2 (B), U104.7 (CANH)
CANID1: R104.2, SW101.1, U102.25 (PA15)
CANID2: R105.2, SW101.2, U102.28 (PB5)
CANID3: R106.2, SW101.3, U102.29 (PB6)
CANID4: R107.2, SW101.4, U102.30 (PB7)
CANL: J104.3, J105.3, R112.2, U104.6 (CANL)
CANRX: U102.21 (PA11), U104.4 (RXD)
CANTX: U102.22 (PA12), U104.1 (TXD)
CCW_M1: U102.7 (PA1); also elsewhere on the board
CCW_M2: U102.9 (PA3); also elsewhere on the board
CCW_M3: U102.13 (PA7); also elsewhere on the board
CCW_M4: U102.15 (PB1); also elsewhere on the board
CW_M1: U102.6 (PA0); also elsewhere on the board
CW_M2: U102.8 (PA2); also elsewhere on the board
CW_M3: U102.12 (PA6); also elsewhere on the board
CW_M4: U102.14 (PB0); also elsewhere on the board
GND: C101.1, C102.2, C103.2, C104.2, C105.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, D101.2 (VSS), D102.2 (VSS), D103.2 (VSS), D104.2 (VSS), D105.1 (K), D106.1 (K), J101.5, J101.7, J101.11, J104.4, J105.4, R101.2, R103.2, SW101.5, SW101.6, SW101.7, SW101.8, SW103.2, U101.2 (GND), U102.16 (VSS), U102.32 (VSS), U104.2 (VSS); also elsewhere on the board
GNDA: C106.2, C107.2, C114.2, C115.2, D107.1 (K), D108.1 (K), J102.1, J103.1, U103.2 (GND); also elsewhere on the board
NeoPixel: D101.3 (DIN), U102.18 (PA8)
unnamed: D101.1 (DOUT), D102.3 (DIN)
unnamed: D102.1 (DOUT), D103.3 (DIN)
unnamed: D103.1 (DOUT), D104.3 (DIN)
unnamed: D105.2 (A), R108.2
unnamed: D106.2 (A), R109.2
unnamed: D107.2 (A), R110.2
unnamed: D108.2 (A), R111.2
unnamed: R112.1, SW102.1 (A)
unnamed: R102.2, U101.3 (EN)
unnamed: C101.2, U102.2 (PF0), Y101.2
unnamed: C102.1, U102.3 (PF1), Y101.1
unnamed: R103.1, U104.8 (Rs)
RST: C113.1, SW103.1, U102.4 (NRST)
SWCLK: J101.6, U102.24 (PA14)
SWDIO: J101.4, U102.23 (PA13)
SWO: J101.8, U102.26 (PB3)
TRST: J101.12, U102.27 (PB4)
UARTRX: J101.13, U102.19 (PA9)
UARTTX: J101.14, U102.20 (PA10)

Notes on the sheet:
←TXRXが逆らしい

Parts:
C201, C202, C203, C204: 0.1u; C_0603_1608Metric
C205, C206, C207, C208: 10u; C_0805_2012Metric
C209: 100u; CP_Elec_10x10.5
D201, D202, D203, D204, D205, D206: 1N4148W; D_SOD-123
D207, D208, D209, D210: MS18F; D_SOD-128
J201: XT30; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
Q201, Q202: BC817; SOT-23
Q203, Q204, Q205, Q206: NTMFS5C628NL; ONSemi_SO-8FL_488AA
R201, R202: 1k; R_0603_1608Metric
R203, R204, R215, R216, R217, R218: 10k; R_0603_1608Metric
R205, R206: 20k; R_0603_1608Metric
R207, R208, R209, R210, R211, R212, R213, R214: 10; R_0603_1608Metric
U201, U202: UCC21330; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3.3V: C201.1, C202.1, R203.1, R204.1, U201.3 (VCCI), U201.8 (VCCI), U202.3 (VCCI), U202.8 (VCCI); also elsewhere on the board
+12V: C206.1, C208.1, D201.2 (A), D202.2 (A), U201.11 (VDDB), U202.11 (VDDB); also elsewhere on the board
+BATT: C209.1, D207.1 (K), D209.1 (K), Q203.5 (D), Q205.5 (D); also elsewhere on the board
CCW_M1: R202.1, U202.1 (INA); also elsewhere on the board
CW_M1: R201.1, U201.1 (INA); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, Q201.2 (E), Q202.2 (E), R205.2, R206.2, U201.4 (GND), U201.5 (DIS), U202.4 (GND), U202.5 (DIS); also elsewhere on the board
GNDA: C206.2, C208.2, C209.2, D208.2 (A), D210.2 (A), Q204.1 (S), Q204.2 (S), Q204.3 (S), Q206.1 (S), Q206.2 (S), Q206.3 (S), R216.1, R218.1, U201.9 (VSSB), U202.9 (VSSB); also elsewhere on the board
unnamed: C205.1, D201.1 (K), U201.16 (VDDA)
unnamed: C207.1, D202.1 (K), U202.16 (VDDA)
unnamed: D203.2 (A), Q203.4 (G), R211.2, R215.2
unnamed: D203.1 (K), R207.2
unnamed: D204.2 (A), Q204.4 (G), R212.2, R216.2
unnamed: D204.1 (K), R208.2
unnamed: D205.2 (A), Q205.4 (G), R213.2, R217.2
unnamed: D205.1 (K), R209.2
unnamed: D206.2 (A), Q206.4 (G), R214.2, R218.2
unnamed: D206.1 (K), R210.2
unnamed: C205.2, D207.2 (A), D208.1 (K), J201.2, Q203.1 (S), Q203.2 (S), Q203.3 (S), Q204.5 (D), R215.1, U201.14 (VSSA)
unnamed: C207.2, D209.2 (A), D210.1 (K), J201.1, Q205.1 (S), Q205.2 (S), Q205.3 (S), Q206.5 (D), R217.1, U202.14 (VSSA)
unnamed: Q201.1 (B), R201.2
unnamed: Q201.3 (C), R203.2, U201.2 (INB)
unnamed: Q202.1 (B), R202.2
unnamed: Q202.3 (C), R204.2, U202.2 (INB)
unnamed: C203.1, R205.1, U201.6 (DT)
unnamed: R207.1, R211.1, U201.15 (OUTA)
unnamed: R208.1, R212.1, U201.10 (OUTB)
unnamed: C204.1, R206.1, U202.6 (DT)
unnamed: R209.1, R213.1, U202.15 (OUTA)
unnamed: R210.1, R214.1, U202.10 (OUTB)

Parts of its further copies:
C301, C302, C303, C304, C401, C402, C403, C404, C501, C502, C503, C504: 0.1u; C_0603_1608Metric
C305, C306, C307, C308, C405, C406, C407, C408, C505, C506, C507, C508: 10u; C_0805_2012Metric
C309, C409, C509: 100u; CP_Elec_10x10.5
D301, D302, D303, D304, D305, D306, D401, D402, D403, D404, D405, D406, D501, D502, D503, D504, D505, D506: 1N4148W; D_SOD-123
D307, D308, D309, D310, D407, D408, D409, D410, D507, D508, D509, D510: MS18F; D_SOD-128
J301, J401, J501: XT30; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
Q301, Q302, Q401, Q402, Q501, Q502: BC817; SOT-23
Q303, Q304, Q305, Q306, Q403, Q404, Q405, Q406, Q503, Q504, Q505, Q506: NTMFS5C628NL; ONSemi_SO-8FL_488AA
R301, R302, R401, R402, R501, R502: 1k; R_0603_1608Metric
R303, R304, R315, R316, R317, R318, R403, R404, R415, R416, R417, R418, R503, R504, R515, R516, R517, R518: 10k; R_0603_1608Metric
R305, R306, R405, R406, R505, R506: 20k; R_0603_1608Metric
R307, R308, R309, R310, R311, R312, R313, R314, R407, R408, R409, R410, R411, R412, R413, R414, R507, R508, R509, R510, R511, R512, R513, R514: 10; R_0603_1608Metric
U301, U302, U401, U402, U501, U502: UCC21330; SOIC-16_3.9x9.9mm_P1.27mm

Connections of its further copies:
+3.3V: C301.1, C302.1, C401.1, C402.1, C501.1, C502.1, R303.1, R304.1, R403.1, R404.1, R503.1, R504.1, U301.3 (VCCI), U301.8 (VCCI), U302.3 (VCCI), U302.8 (VCCI), U401.3 (VCCI), U401.8 (VCCI), U402.3 (VCCI), U402.8 (VCCI), U501.3 (VCCI), U501.8 (VCCI), U502.3 (VCCI), U502.8 (VCCI); also elsewhere on the board
+12V: C306.1, C308.1, C406.1, C408.1, C506.1, C508.1, D301.2 (A), D302.2 (A), D401.2 (A), D402.2 (A), D501.2 (A), D502.2 (A), U301.11 (VDDB), U302.11 (VDDB), U401.11 (VDDB), U402.11 (VDDB), U501.11 (VDDB), U502.11 (VDDB); also elsewhere on the board
+BATT: C309.1, C409.1, C509.1, D307.1 (K), D309.1 (K), D407.1 (K), D409.1 (K), D507.1 (K), D509.1 (K), Q303.5 (D), Q305.5 (D), Q403.5 (D), Q405.5 (D), Q503.5 (D), Q505.5 (D); also elsewhere on the board
CCW_M2: R302.1, U302.1 (INA); also elsewhere on the board
CCW_M3: R402.1, U402.1 (INA); also elsewhere on the board
CCW_M4: R502.1, U502.1 (INA); also elsewhere on the board
CW_M2: R301.1, U301.1 (INA); also elsewhere on the board
CW_M3: R401.1, U401.1 (INA); also elsewhere on the board
CW_M4: R501.1, U501.1 (INA); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C401.2, C402.2, C403.2, C404.2, C501.2, C502.2, C503.2, C504.2, Q301.2 (E), Q302.2 (E), Q401.2 (E), Q402.2 (E), Q501.2 (E), Q502.2 (E), R305.2, R306.2, R405.2, R406.2, R505.2, R506.2, U301.4 (GND), U301.5 (DIS), U302.4 (GND), U302.5 (DIS), U401.4 (GND), U401.5 (DIS), U402.4 (GND), U402.5 (DIS), U501.4 (GND), U501.5 (DIS), U502.4 (GND), U502.5 (DIS); also elsewhere on the board
GNDA: C306.2, C308.2, C309.2, C406.2, C408.2, C409.2, C506.2, C508.2, C509.2, D308.2 (A), D310.2 (A), D408.2 (A), D410.2 (A), D508.2 (A), D510.2 (A), Q304.1 (S), Q304.2 (S), Q304.3 (S), Q306.1 (S), Q306.2 (S), Q306.3 (S), Q404.1 (S), Q404.2 (S), Q404.3 (S), Q406.1 (S), Q406.2 (S), Q406.3 (S), Q504.1 (S), Q504.2 (S), Q504.3 (S), Q506.1 (S), Q506.2 (S), Q506.3 (S), R316.1, R318.1, R416.1, R418.1, R516.1, R518.1, U301.9 (VSSB), U302.9 (VSSB), U401.9 (VSSB), U402.9 (VSSB), U501.9 (VSSB), U502.9 (VSSB); also elsewhere on the board
unnamed: C305.1, D301.1 (K), U301.16 (VDDA)
unnamed: C307.1, D302.1 (K), U302.16 (VDDA)
unnamed: D303.2 (A), Q303.4 (G), R311.2, R315.2
unnamed: D303.1 (K), R307.2
unnamed: D304.2 (A), Q304.4 (G), R312.2, R316.2
unnamed: D304.1 (K), R308.2
unnamed: D305.2 (A), Q305.4 (G), R313.2, R317.2
unnamed: D305.1 (K), R309.2
unnamed: D306.2 (A), Q306.4 (G), R314.2, R318.2
unnamed: D306.1 (K), R310.2
unnamed: C305.2, D307.2 (A), D308.1 (K), J301.2, Q303.1 (S), Q303.2 (S), Q303.3 (S), Q304.5 (D), R315.1, U301.14 (VSSA)
unnamed: C307.2, D309.2 (A), D310.1 (K), J301.1, Q305.1 (S), Q305.2 (S), Q305.3 (S), Q306.5 (D), R317.1, U302.14 (VSSA)
unnamed: C405.1, D401.1 (K), U401.16 (VDDA)
unnamed: C407.1, D402.1 (K), U402.16 (VDDA)
unnamed: D403.2 (A), Q403.4 (G), R411.2, R415.2
unnamed: D403.1 (K), R407.2
unnamed: D404.2 (A), Q404.4 (G), R412.2, R416.2
unnamed: D404.1 (K), R408.2
unnamed: D405.2 (A), Q405.4 (G), R413.2, R417.2
unnamed: D405.1 (K), R409.2
unnamed: D406.2 (A), Q406.4 (G), R414.2, R418.2
unnamed: D406.1 (K), R410.2
unnamed: C405.2, D407.2 (A), D408.1 (K), J401.2, Q403.1 (S), Q403.2 (S), Q403.3 (S), Q404.5 (D), R415.1, U401.14 (VSSA)
unnamed: C407.2, D409.2 (A), D410.1 (K), J401.1, Q405.1 (S), Q405.2 (S), Q405.3 (S), Q406.5 (D), R417.1, U402.14 (VSSA)
unnamed: C505.1, D501.1 (K), U501.16 (VDDA)
unnamed: C507.1, D502.1 (K), U502.16 (VDDA)
unnamed: D503.2 (A), Q503.4 (G), R511.2, R515.2
unnamed: D503.1 (K), R507.2
unnamed: D504.2 (A), Q504.4 (G), R512.2, R516.2
unnamed: D504.1 (K), R508.2
unnamed: D505.2 (A), Q505.4 (G), R513.2, R517.2
unnamed: D505.1 (K), R509.2
unnamed: D506.2 (A), Q506.4 (G), R514.2, R518.2
unnamed: D506.1 (K), R510.2
unnamed: C505.2, D507.2 (A), D508.1 (K), J501.2, Q503.1 (S), Q503.2 (S), Q503.3 (S), Q504.5 (D), R515.1, U501.14 (VSSA)
unnamed: C507.2, D509.2 (A), D510.1 (K), J501.1, Q505.1 (S), Q505.2 (S), Q505.3 (S), Q506.5 (D), R517.1, U502.14 (VSSA)
unnamed: Q301.1 (B), R301.2
unnamed: Q301.3 (C), R303.2, U301.2 (INB)
unnamed: Q302.1 (B), R302.2
unnamed: Q302.3 (C), R304.2, U302.2 (INB)
unnamed: Q401.1 (B), R401.2
unnamed: Q401.3 (C), R403.2, U401.2 (INB)
unnamed: Q402.1 (B), R402.2
unnamed: Q402.3 (C), R404.2, U402.2 (INB)
unnamed: Q501.1 (B), R501.2
unnamed: Q501.3 (C), R503.2, U501.2 (INB)
unnamed: Q502.1 (B), R502.2
unnamed: Q502.3 (C), R504.2, U502.2 (INB)
unnamed: C303.1, R305.1, U301.6 (DT)
unnamed: R307.1, R311.1, U301.15 (OUTA)
unnamed: R308.1, R312.1, U301.10 (OUTB)
unnamed: C304.1, R306.1, U302.6 (DT)
unnamed: R309.1, R313.1, U302.15 (OUTA)
unnamed: R310.1, R314.1, U302.10 (OUTB)
unnamed: C403.1, R405.1, U401.6 (DT)
unnamed: R407.1, R411.1, U401.15 (OUTA)
unnamed: R408.1, R412.1, U401.10 (OUTB)
unnamed: C404.1, R406.1, U402.6 (DT)
unnamed: R409.1, R413.1, U402.15 (OUTA)
unnamed: R410.1, R414.1, U402.10 (OUTB)
unnamed: C503.1, R505.1, U501.6 (DT)
unnamed: R507.1, R511.1, U501.15 (OUTA)
unnamed: R508.1, R512.1, U501.10 (OUTB)
unnamed: C504.1, R506.1, U502.6 (DT)
unnamed: R509.1, R513.1, U502.15 (OUTA)
unnamed: R510.1, R514.1, U502.10 (OUTB)

Board: 2 copper layers, 100.0 x 100.0 mm, 233 parts (0 on the bottom side), 132 nets.
